# Keil uVision project ssl_client_demo.uvproj, settings and files
target ssl_client_demo_flash (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ssl_client_demo_flash +hex
  AfterMake: fromelf --bin !L --output IP+PDU-1-32.bin
  c flags: Optim=1
  c define: STM32F4XX USE_STM32F4_DISCOVERY USE_STDPERIPH_DRIVER
  c include: ..\src;..\..\..\..\common\cmsis;..\..\..\..\common\st\devices\stm32f4xx;..\..\..\..\common\st\stm32f4xx_std_periph_lib\inc;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto;..\resources;..\HARDWARE\Headers
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_flash.sct
  link misc: --diag_suppress=L6314,L6305
  group Demo Sources
    ./: startup_stm32f4xx.s retarget.c
    ../src/: system_stm32f4xx.c stm32f4xx_it.c main.c debug.c res.c
    ../HARDWARE/: application.c
    ../HARDWARE/Sources/: event_groups.c
  group HARDWARE
    ../HARDWARE/Sources/: bsp_key.c led.c sys.c flash_if.c private_mib_impl.c private_mib_module.c temhum.c TIM.c tftpserver.c 24c04-iic.c exti.c spi.c w25qxx.c function.c telnet.c modbus.c send_smtp.c snmp_trap.c debugudp.c rn8207.c lcd.c spi3.c display.c web.c
  group Common Sources
    ../../../../../common/: endian.c os_port_freertos.c date_time.c str.c resource_manager.c path.c
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c nic.c ethernet.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c bsd_socket.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/: stm32f4x7_eth.c lan8720.c
    ../../../../../cyclone_tcp/ipv4/: arp.c ipv4.c ipv4_frag.c icmp.c igmp.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: mime.c http_server.c http_server_auth.c http_server_misc.c ssi.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_misc.c snmp_agent_pdu.c snmp_common.c snmp_usm.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c mib2_impl.c mib2_module.c
    ../../../../../cyclone_tcp/smtp/: smtp_client.c
    ../../../../../cyclone_tcp/sntp/: sntp_client.c
  group CycloneSSL Sources
    ../../../../../cyclone_ssl/: tls.c tls_cipher_suites.c tls_client.c tls_server.c tls_common.c tls_record.c tls_io.c tls_misc.c tls_cache.c ssl_common.c
  group CycloneCrypto Sources
    ../../../../../cyclone_crypto/: base64.c md2.c md4.c md5.c ripemd128.c ripemd160.c sha1.c sha224.c sha256.c sha384.c sha512.c sha512_224.c sha512_256.c tiger.c whirlpool.c hmac.c rc4.c rc6.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c cipher_mode_ecb.c cipher_mode_cbc.c cipher_mode_cfb.c cipher_mode_ofb.c cipher_mode_ctr.c cipher_mode_ccm.c cipher_mode_gcm.c dh.c rsa.c dsa.c ec.c ec_curves.c ecdh.c ecdsa.c pkcs5.c mpi.c mpi_asm_keil_cortex_m3.s asn1.c oid.c x509.c pem.c yarrow.c
  group FreeRTOS Sources
    ../../../../common/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../common/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../common/freertos/portable/memmang/: heap_3.c
  group STM32F4xx Std Periph Lib Sources
    ../../../../common/st/stm32f4xx_std_periph_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
target ssl_client_demo_sram (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: ssl_client_demo_sram
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1
  c define: STM32F4XX USE_STM32F4_DISCOVERY USE_STDPERIPH_DRIVER
  c include: ..\src;..\..\..\..\common\cmsis\include;..\..\..\..\common\st\devices\stm32f4xx;..\..\..\..\common\st\boards;..\..\..\..\common\st\boards\common;..\..\..\..\common\st\boards\stm32f4_discovery;..\..\..\..\common\st\stm32f4xx_std_periph_lib\inc;..\..\..\..\common\freertos\include;..\..\..\..\common\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_ssl;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32f407_sram.sct
